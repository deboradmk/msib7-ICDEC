v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pmoscs.sym} 1810 -1530 0 0 {name=x1}
C {nmoscs.sym} 1810 -1370 0 0 {name=x2}
C {pmoscs2.sym} 2260 -1530 0 1 {name=x3}
C {nmoscs2.sym} 2270 -1380 0 1 {name=x4}
C {devices/lab_pin.sym} 2110 -1560 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2110 -1540 0 0 {name=p2 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 2110 -1520 0 0 {name=p3 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 2110 -1500 0 0 {name=p4 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 2120 -1400 0 0 {name=p5 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 2120 -1380 0 0 {name=p6 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 2120 -1360 0 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1960 -1340 2 0 {name=p8 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1960 -1360 2 0 {name=p9 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 1960 -1380 2 0 {name=p10 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 1960 -1400 2 0 {name=p11 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 1960 -1500 2 0 {name=p12 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 1960 -1520 2 0 {name=p13 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 1960 -1540 2 0 {name=p14 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 1960 -1560 2 0 {name=p15 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2410 -1560 2 0 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 2410 -1540 2 0 {name=p17 sig_type=std_logic lab=VIP}
C {devices/iopin.sym} 1960 -1610 3 0 {name=p18 lab=VDD}
C {devices/iopin.sym} 1980 -1610 3 0 {name=p19 lab=VIN}
C {devices/iopin.sym} 2000 -1610 3 0 {name=p20 lab=VIP}
C {devices/iopin.sym} 2020 -1610 3 0 {name=p21 lab=OUT}
C {devices/iopin.sym} 2040 -1610 3 0 {name=p22 lab=RS}
C {devices/iopin.sym} 2060 -1610 3 0 {name=p23 lab=GND}
